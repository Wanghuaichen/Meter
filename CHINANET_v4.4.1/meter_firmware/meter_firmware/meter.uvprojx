# Keil uVision project meter.uvprojx, settings and files
target meter (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F302CC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: meter
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG,METRE_CLEAR
  c include: .\USER;.\DRIVERS;.\CORE;.\Lib;.\SYS\SYS;.\SYS\DELAY;.\APP\LED;.\SYS\UART;.\SYS\EXIT;.\SYS\KEY;.\APP\INIT;.\SYS\RTC;.\APP\NB;.\APP\METER;.\SYS\FLASH;.\APP\TIMER;.\APP\TASK;.\APP\WDOG;.\APP\ADC;.\APP\ENCODE;.\APP\ALARM;.\APP\VERSION;.\APP\IP;.\APP\include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group USER
    ./USER/: main.c
  group CORE
    ./CORE/: startup_stm32f302xc.s system_stm32f30x.c
  group SYS
    ./SYS/DELAY/: delay.c
    ./SYS/SYS/: sys.c
    ./SYS/UART/: usart.c
    ./SYS/FLASH/: flash.c
    ./SYS/RTC/: rtc.c
    ./SYS/EXIT/: exit.c
    ./SYS/KEY/: key.c
  group LIB
    ./Lib/: misc.c stm32f30x_gpio.c stm32f30x_rcc.c stm32f30x_usart.c stm32f30x_flash.c stm32f30x_rtc.c stm32f30x_exti.c stm32f30x_pwr.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_iwdg.c stm32f30x_adc.c
  group APP
    ./APP/LED/: led.c
    ./APP/INIT/: init.c
    ./APP/NB/: nb.c
    ./APP/METER/: meter.c
    ./APP/ADDR/: data.c
    ./APP/TIMER/: timer.c
    ./APP/TASK/: task.c
    ./APP/WDOG/: wdog.c
    ./APP/ADC/: adc.c
    ./APP/ENCODE/: encode.c
    ./APP/ALARM/: alarm.c
    ./APP/CLOCK/: clock.c
    ./APP/VERSION/: version.c
    ./APP/IP/: ip.c
    ./APP/source/: fre.c
